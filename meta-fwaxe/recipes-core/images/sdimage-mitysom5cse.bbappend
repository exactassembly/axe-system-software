KERNEL_DEVICETREE += "\
    socfpga_mitysom5cse_l23y8_fwaxe.dtb \
    "