FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_A10S_HPS = "mitysom_a10s_hps.xml"